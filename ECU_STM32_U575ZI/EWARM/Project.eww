<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ECU_STM32_U575ZI.ewp</path>
  </project>
  <batchBuild />
</workspace>
