# IAR project ECU_STM32_U575ZI.ewp, settings and files
configuration ECU_STM32_U575ZI (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U575xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc; ../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include/; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../Middlewares/Third_Party/CMSIS/RTOS2/Include/; ..\..\ECU_CTL\app; ..\..\ECU_CTL\app\shell_cmd; ..\..\ECU_CTL\devices; ..\..\ECU_CTL\drivers; ..\..\ECU_CTL\drivers\EC800M; ..\..\ECU_CTL\middlewares; ..\..\ECU_CTL\middlewares\at_com; ..\..\ECU_CTL\middlewares\EasyLogger\inc; ..\..\ECU_CTL\middlewares\LetterShell\src; ..\..\ECU_CTL\middlewares\LetterShell\extensions\shell_enhance; ..\..\ECU_CTL\middlewares\net_agreement; ..\..\ECU_CTL\middlewares\soft_aes; ..\..\ECU_CTL\drivers\U575
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: ECU_STM32_U575ZI.hex
  ILINK.IlinkOutputFile: ECU_STM32_U575ZI.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c gpdma.c icache.c memorymap.c octospi.c rtc.c usart.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_ospi.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group ECU_CTL/app
    ../../ECU_CTL/app/: ecu_unit.c net_unit.c version.c
  group ECU_CTL/app/shell_cmd
    ../../ECU_CTL/app/shell_cmd/: t_boot.c t_cmd_test.c
  group ECU_CTL/devices
    ../../ECU_CTL/devices/: bms_port.c console.c ebike_manage.c mcu_ctl.c net_port.c ota_file_manage.c shell_port.c utc.c
  group ECU_CTL/drivers
    ../../ECU_CTL/drivers/: driver_com.c
  group ECU_CTL/drivers/ec800m
    ../../ECU_CTL/drivers/EC800M/: ec800m_drv_at.c
  group ECU_CTL/drivers/U575
    ../../ECU_CTL/drivers/U575/: driver_mcu.c driver_pin_ec800m.c driver_rtc.c drv_usart.c
  group ECU_CTL/middleware
    ../../ECU_CTL/middlewares/: fault.c ring_buffer.c user_comm.c user_crc.c user_list.c
  group ECU_CTL/middleware/at_com
    ../../ECU_CTL/middlewares/at_com/: at_com.c
  group ECU_CTL/middleware/EasyLogger
    ../../ECU_CTL/middlewares/EasyLogger/src/: elog.c elog_utils.c
    ../../ECU_CTL/middlewares/EasyLogger/port/: elog_port.c
  group ECU_CTL/middleware/LetterShell/core
    ../../ECU_CTL/middlewares/LetterShell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
  group ECU_CTL/middleware/LetterShell/shell_enhance
    ../../ECU_CTL/middlewares/LetterShell/extensions/shell_enhance/: shell_cmd_group.c shell_passthrough.c shell_secure_user.c
  group ECU_CTL/middleware/net_agreement
    ../../ECU_CTL/middlewares/net_agreement/: net_agreement.c
  group ECU_CTL/middleware/soft_aes
    ../../ECU_CTL/middlewares/soft_aes/: aes.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: portasm.s port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
