# IAR project ECU_STM32_407.ewp, settings and files
configuration ECU_STM32_407 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; STM32_THREAD_SAFE_STRATEGY=4
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\..\ECU_CTL\app; ..\..\ECU_CTL\devices; ..\..\ECU_CTL\drivers\EC800M; ..\..\ECU_CTL\drivers; ..\..\ECU_CTL\middlewares\at_com; ..\..\ECU_CTL\middlewares; ..\..\ECU_CTL\middlewares\EasyLogger\inc; ..\..\ECU_CTL\middlewares\LetterShell\src; ..\..\ECU_CTL\middlewares\LetterShell\extensions\shell_enhance; ..\..\ECU_CTL\middlewares\soft_aes; ..\..\ECU_CTL\middlewares\net_agreement; ..\..\ECU_CTL\drivers\F407; ..\..\ECU_CTL\middlewares\littlefs; ..\..\ECU_CTL\middlewares\md5
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: ECU_STM32_407.bin
  ILINK.IlinkOutputFile: ECU_STM32_407.out
  ILINK.IlinkIcfFile: ../EWARM/stm32f407xx_flash_debug.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ECU_STM32_407_RELEASE (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; STM32_THREAD_SAFE_STRATEGY=4; _RELEASE_
  ILINK.IlinkIcfFile: ../EWARM/stm32f407xx_flash_release.icf
  group Application/EWARM
    ../EWARM/: dlib_lock_glue.c startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: dma.c freertos.c gpio.c main.c rtc.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group ECU_CTL/app
    ../../ECU_CTL/app/: ecu_unit.c net_unit.c test.c version.c
  group ECU_CTL/app/shell_cmd
    ../../ECU_CTL/app/shell_cmd/: t_boot.c t_cmd_test.c t_ex_flash.c t_file.c
  group ECU_CTL/devices
    ../../ECU_CTL/devices/: bk_config.c bms_port.c console.c ebike_manage.c ex_flash.c lfs_port.c mcu_ctl.c net_port.c ota_file_manage.c shell_port.c utc.c
  group ECU_CTL/drivers
    ../../ECU_CTL/drivers/: console.c driver_com.c
  group ECU_CTL/drivers/EC800M
    ../../ECU_CTL/drivers/EC800M/: ec800m_drv_at.c
  group ECU_CTL/drivers/F407
    ../../ECU_CTL/drivers/F407/: driver_bk_sram.c driver_mcu.c driver_pin_ec800m.c driver_rtc.c driver_w25q128.c drv_usart.c
  group ECU_CTL/middlewares
    ../../ECU_CTL/middlewares/: fault.c ring_buffer.c user_comm.c user_crc.c user_list.c
  group ECU_CTL/middlewares/at_com
    ../../ECU_CTL/middlewares/at_com/: at_com.c at_com.h
  group ECU_CTL/middlewares/EasyLogger
    ../../ECU_CTL/middlewares/EasyLogger/src/: elog.c elog_utils.c
    ../../ECU_CTL/middlewares/EasyLogger/port/: elog_port.c
  group ECU_CTL/middlewares/LetterShell/core
    ../../ECU_CTL/middlewares/LetterShell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
  group ECU_CTL/middlewares/LetterShell/shell_enhance
    ../../ECU_CTL/middlewares/LetterShell/extensions/shell_enhance/: shell_cmd_group.c shell_passthrough.c shell_secure_user.c
  group ECU_CTL/middlewares/littlefs
    ../../ECU_CTL/middlewares/littlefs/: lfs.c lfs_util.c
  group ECU_CTL/middlewares/md5
    ../../ECU_CTL/middlewares/md5/: md5.c
  group ECU_CTL/middlewares/net_agreement
    ../../ECU_CTL/middlewares/net_agreement/: net_agreement.c
  group ECU_CTL/middlewares/soft_aes
    ../../ECU_CTL/middlewares/soft_aes/: aes.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
